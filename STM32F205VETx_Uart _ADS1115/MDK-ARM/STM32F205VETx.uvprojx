# Keil uVision project STM32F205VETx.uvprojx, settings and files
target STM32F205VETx (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F205VETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) CPUTYPE("Cortex-M3") TZ
  output: STM32F205VETx +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F205xx
  c include: ../Core/Inc;../Drivers/STM32F2xx_HAL_Driver/Inc;../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../Drivers/CMSIS/Include;../LOG;../MDK-ARM;../Sort;../PID;../CONTROL;../CONTROL/Digitalpower;../ADS1115
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f205xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c i2c.c tim.c usart.c stm32f2xx_it.c stm32f2xx_hal_msp.c stm32f2xx_hal_timebase_tim.c
  group LOG
    ../LOG/: log.c
  group Sort
    ../Sort/: sort.c
  group PID
    ../PID/: pid.c
  group PowerControl
    ../CONTROL/Digitalpower/: power.c power.h
  group ADS1115
    ../ADS1115/: ADS1115.c ADS1115.h
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_exti.c stm32f2xx_hal_i2c.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f2xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 4.3.0
